<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pca10056\s140\iar\ble_app_template_pca10056_s140.ewp</path>
    </project>
    <batchBuild />
</workspace>
